options:
  parameters:
    generate_options: no_gui
    id: hd_tx_usrp
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 87.5e6
  states: {}
- name: lsb_power_db
  id: variable
  parameters:
    comment: |-
      Total power in the lower
      sideband relative to the
      FM carrier (-23 to -13 dB)
    value: '-13'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: usb_power_db
  id: variable
  parameters:
    comment: |-
      Total power in the upper
      sideband relative to the
      FM carrier (-23 to -13 dB)
    value: '-13'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate * 4
    tau: '75e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(audio_rate * 4.458)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '2160'
    n: '4096'
    offset: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.35'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '[10**(lsb_power_db/20) * math.sqrt((135/128) * (1/2) * (1/191))]*1024 + [10**(usb_power_db/20) * math.sqrt((135/128) * (1/2) * (1/191))]*1024'
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[math.sin(math.pi / 2 * i / 112) for i in range(112)] + [1] * (2048-112) + [math.cos(math.pi / 2 * i / 112) for i in range(112)]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: sample.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: sample_mono.wav
    repeat: 'True'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52004'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52000'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '64000'
    channels: '2'
  states: {}
- name: nrsc5_l1_fm_encoder_mp1_0
  id: nrsc5_l1_fm_encoder_mp1
  parameters: {}
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    blend_control: nrsc5.blend.ENABLE
    ccc_width: '24'
    data_bytes: '2000'
    first_prog: '0'
    num_progs: '1'
    size: '146176'
  states: {}
- name: nrsc5_lot_encoder_0
  id: nrsc5_lot_encoder
  parameters:
    filename: SLABCD$$010000.png
    lot_id: '42'
    port: '0x1001'
  states: {}
- name: nrsc5_lot_encoder_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: album_art.jpg
    lot_id: '1337'
    port: '0x1000'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: Artist
    bytes_per_frame: '128'
    prog_num: '0'
    title: Title
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    altitude: '93.0'
    country_code: US
    emergency_alerts: 'False'
    fcc_facility_id: '0'
    latitude: '40.6892'
    longitude: '-74.0445'
    message: Generated by GNU Radio
    mode: nrsc5.pids_mode.FM
    num_programs: '1'
    program_name0: HD1
    program_name1: HD2
    program_name2: HD3
    program_name3: HD4
    program_name4: HD5
    program_name5: HD6
    program_name6: HD7
    program_name7: HD8
    program_type0: nrsc5.program_type.NEWS
    program_type1: nrsc5.program_type.NEWS
    program_type2: nrsc5.program_type.NEWS
    program_type3: nrsc5.program_type.NEWS
    program_type4: nrsc5.program_type.NEWS
    program_type5: nrsc5.program_type.NEWS
    program_type6: nrsc5.program_type.NEWS
    program_type7: nrsc5.program_type.NEWS
    short_name: ABCD-FM
    slogan: This is ABCD-FM
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    interp: '50'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '49'
    interp: '125'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '243'
    interp: '256'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=128"'
    gain0: '70'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_conjugate_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_delay_0, '0', analog_wfm_tx_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', fft_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_repeat_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_wavfile_source_0, '0', nrsc5_hdc_encoder_0, '0']
- [blocks_wavfile_source_0, '1', nrsc5_hdc_encoder_0, '1']
- [blocks_wavfile_source_1, '0', blocks_delay_0, '0']
- [fft_vxx_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [network_socket_pdu_0, pdus, nrsc5_lot_encoder_0_0, file]
- [network_socket_pdu_0_0, pdus, nrsc5_sis_encoder_0, command]
- [network_socket_pdu_1, pdus, nrsc5_psd_encoder_0, set_meta]
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_l1_fm_encoder_mp1_0, '0', blocks_multiply_const_vxx_2, '0']
- [nrsc5_l1_fm_encoder_mp1_0, clock, nrsc5_psd_encoder_0, clock]
- [nrsc5_l1_fm_encoder_mp1_0, clock, nrsc5_sis_encoder_0, clock]
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_fm_encoder_mp1_0, '0']
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_sis_encoder_0, ready]
- [nrsc5_lot_encoder_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_fm_encoder_mp1_0, '1']
- [nrsc5_sis_encoder_0, aas, nrsc5_l2_encoder_0, aas]
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
